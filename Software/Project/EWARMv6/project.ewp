# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\CMSIS\Include; ..\..\User\bsp; ..\..\User\bsp\inc; ..\..\uCOS-II\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\uCOS-II\uCOS-II\Source; ..\..\uCOS-II\uC-LIB; ..\..\uCOS-II\uC-LIB\Ports\ARM-Cortex-M3\IAR; ..\..\uCOS-II\uC-CPU; ..\..\uCOS-II\uC-CPU\ARM-Cortex-M3\IAR; ..\..\User
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  postbuild: CopyHex_Flash.bat
  ILINK.IlinkOutputFile: stm32-f1.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f10x_assert.c stm32f10x_it.c
    ../../User/bsp/src/: bsp_key.c bsp_led.c bsp_uart_fifo.c bsp_user_lib.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group EWARMv6
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_hd.s
  group Stdperiph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c
  group uC/CPU
    ../../uCOS-II/uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../../uCOS-II/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../../uCOS-II/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../uCOS-II/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uC/OS-II Port
    ../../uCOS-II/uCOS-II/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-II Source
    ../../uCOS-II/uCOS-II/Source/: os.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group User
    ../../User/: app.c app_cfg.h app_hooks.c cpu_bsp.c cpu_cfg.h includes.h lib_cfg.h os_cfg.h
