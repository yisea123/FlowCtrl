# Keil uVision project project.uvproj, settings and files
target Flash (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User\bsp\inc;..\..\uCOS-II\uCOS-II\Ports\ARM-Cortex-M3\Generic\RealView;..\..\uCOS-II\uCOS-II\Source;..\..\uCOS-II\uC-LIB;..\..\uCOS-II\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\..\uCOS-II\uC-CPU;..\..\uCOS-II\uC-CPU\ARM-Cortex-M3\RealView;..\..\User;..\..\Libraries\CMSIS\Include;..\..\Libraries\ABCC\abcc_abp;..\..\Libraries\ABCC\abcc_adapt;..\..\Libraries\ABCC\abcc_drv\inc;..\..\Libraries\ABCC\abcc_drv\src;..\..\Libraries\ABCC\abcc_drv\src\spi;..\..\Libraries\ABCC\abcc_obj;..\..\Libraries\ABCC\abcc_obj\nw_obj;..\..\Libraries\ABCC\example_app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../../User/: app.c cpu_bsp.c app_hooks.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_cfg.h
  group BSP
    ../../User/bsp/: bsp.h bsp.c stm32f10x_it.c stm32f10x_assert.c
    ../../User/bsp/src/: bsp_key.c bsp_led.c bsp_uart_fifo.c bsp_user_lib.c bsp_tm1638.c bsp_adc1.c bsp_spi_flash.c bsp_spi_bus.c bsp_io.c bsp_sensor.c bsp_abcc.c bsp_cpu_rtc.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group uC/CPU
    ../../uCOS-II/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../uCOS-II/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../uCOS-II/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../uCOS-II/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-II Source
    ../../uCOS-II/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uC/OS-II Port
    ../../uCOS-II/uCOS-II/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group ABCC
    ../../Libraries/ABCC/abcc_adapt/: abcc_sw_port.c abcc_sys_adapt.c
    ../../Libraries/ABCC/abcc_drv/src/: abcc_debug_err.c abcc_handler.c abcc_link.c abcc_mem.c abcc_remap.c abcc_setup.c abcc_timer.c abcc_cmd_seq.c
    ../../Libraries/ABCC/abcc_drv/src/spi/: abcc_crc32.c abcc_handler_spi.c abcc_spi_drv.c
    ../../Libraries/ABCC/abcc_obj/: ad_obj.c app_obj.c etn_obj.c sync_obj.c
    ../../Libraries/ABCC/abcc_obj/nw_obj/: eip.c epl.c prt.c cop.c dev.c dpv1.c ect.c mod.c
  group ABCC_APP
    ../../Libraries/ABCC/example_app/: appl_abcc_handler.c appl_adimap_alltypes.c appl_adimap_separate16.c appl_adimap_simple16.c appl_adimap_sync.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.开发环境说明.txt ReleaseNote.txt
    ./: 说明.txt
